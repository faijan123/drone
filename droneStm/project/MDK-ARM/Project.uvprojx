# Keil uVision project Project.uvprojx, settings and files
target TCopter (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F427VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F427_437xx +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F427_437xx, HSE_VALUE = 8000000
  c misc: --C99
  c include: ..\..\project;..\MDK-ARM;..\..\libs\lowlayer\STM32F4xx_StdPeriph_Driver\inc;..\..\libs\lowlayer\CMSIS\Include;..\..\libs\lowlayer\CMSIS\Device\ST\STM32F4xx\Include;..\..\libs\service\gpio;..\..\libs\service\delay;..\..\libs\service\uart;..\..\libs\service\i2c;..\..\libs\service\timer;..\..\libs\service\timerutil;..\..\libs\service\controller;..\..\libs\service\mapper;..\..\libs\service\systemtick;..\..\libs\service\time;..\..\libs\service\motorcontrol;..\..\libs\service\mpu9250;..\..\libs\service\tileni2c;..\..\libs\service\data;..\..\libs\service\util;..\..\libs\service\calibrate;..\..\libs\service\pid;..\..\libs\service\eulercalculator;..\..\libs\application\config;..\..\libs\application\core;..\..\libs\application\imublock;..\..\libs\application\printer;..\..\libs\application\eulerblock;..\..\libs\application\motorcontrol;..\..\libs\application\flycontrolblock;..\..\libs\service\filter;..\..\libs\service\buffer;..\..\miniprogram\GyroCalibrationProgram;..\..\libs\lowlayer\store;..\..\libs\service\dronestore;..\..\miniprogram\debug;..\..\libs\service\pinstatereader;..\..\libs\service\barometer\ms5611;..\..\miniprogram\altitudecalibrationprogram;..\..\libs\application\altitudeblock;..\..\libs\service\ubx;..\..\libs\service\ublox;..\..\libs\algorithm\holdaltitude;..\..\libs\service\translate;..\..\libs\algorithm\holdposition;..\..\libs\application\gpsb
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group STM32F4xx_StdPeriph_Driver
    ../../libs/lowlayer/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group CMSIS
    ../../libs/lowlayer/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group MDK-ARM
    ../../libs/lowlayer/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427_437xx.s
  group uart
    ../../libs/service/uart/: Uart.h Uart.c
  group interrupt
    ../: stm32f4xx_it.c
    ../../libs/application/flycontroller/: FlyDrone.h
  group i2c
    ../../libs/service/i2c/: i2c.c i2c.h i2ctimeout.c
  group flash
    ../../libs/lowlayer/store/: FlashReader.c FlashReader.h FlashWriter.c FlashWriter.h
  group tileni2c
    ../../libs/service/tileni2c/: attributes.h defines.h tm_stm32f4_gpio.c tm_stm32f4_gpio.h tm_stm32f4_i2c.c tm_stm32f4_i2c.h
  group delay
    ../../libs/service/delay/: Delay.h Delay.c
  group time
    ../../libs/service/time/: Delay.c Delay.h SystemTime.c SystemTime.h Timeout.c Timeout.h
  group gpio
    ../../libs/service/gpio/: Gpio.c Gpio.h
  group timer
    ../../libs/service/timer/: Timer.h Timer.c
  group pwm
    ../../libs/service/pwm/: Pwm.h
  group systick
    ../../libs/service/systemtick/: SystemTick.h SystemTick.c
  group data
    ../../libs/service/data/: Vector2D.c Vector2D.h Vector3D.c Vector3D.h Position.c Position.h Array.h DArray.c Types.h
  group util
    ../../libs/service/util/: Constance.h Constraint.c Constraint.h EulerUtil.h TimeUtil.h ArrayUtil.c ArrayUtil.h CastType.h ByteConverter.c ByteConverter.h AccelUtil.c AccelUtil.h GpsUtil.h GpsUtil.c
  group translate
    ../../libs/service/translate/: Translate.h Translate3D.c Transtate2D.c
  group pid
    ../../libs/service/pid/: Pid.c Pid.h
  group buffer
    ../../libs/service/buffer/: Buffer.h Buffer.c
  group timerutil
    ../../libs/service/timerutil/: TimerUtil.h TimerUtil.c
  group mapper
    ../../libs/service/mapper/: Mapper.h Mapper.c
  group calibrate
    ../../libs/service/calibrate/: ImuCalibrate.c ImuCalibrate.h GyroOffsetCalculator.h GyroOffsetCalculator.c MagnetCalibrate.c MagnetCalibrate.h
  group filter
    ../../libs/service/filter/: Filter.h PositionFilter.c AveFilter.c ComplementeryFilter.c HightPassFilter.c LowPassFilter.c AltitudeFilter.h AltitudeFilter.c GpsFilter.c GpsFilter.h
  group mpu9250
    ../../libs/service/mpu9250/: Mpu9250Reader.c Mpu9250Reader.h tm_stm32f4_mpu9250.c tm_stm32f4_mpu9250.h
  group ms5611
    ../../libs/service/barometer/ms5611/: BarometerMs5611.h BarometerMs5611.c Ms5611EpRomReader.c Ms5611EpRomReader.h Ms5611Calculator.h Ms5611Calculator.c Ms5611Reader.c Ms5611Reader.h
  group eulercalculator
    ../../libs/service/eulercalculator/: EulerCalculator.c EulerCalculator.h
  group holdaltitude
    ../../libs/algorithm/holdaltitude/: HoldAltitude.c HoldAltitude.h
  group holdposition
    ../../libs/algorithm/holdposition/: HoldPosition.c HoldPosition.h
  group pidsystem
    ../../libs/application/core/: QuadCore.c QuadCore.h
  group controller
    ../../libs/service/controller/: SBusReader.h SBusReader.c DroneController.h DroneController.c SbusParser.h SbusParser.c
  group dronestore
    ../../libs/service/dronestore/: DroneStore.c DroneStore.h
  group pinstatereader
    ../../libs/service/pinstatereader/: PinStateReader.c PinStateReader.h PinStateReaderWithDMA.c
  group altitudeblock
    ../../libs/application/altitudeblock/: AltitudeBlock.c AltitudeBlock.h
  group eulerblock
    ../../libs/application/eulerblock/: EulerBlock.h EulerBlock.c
  group imublock
    ../../libs/application/imublock/: ImuBlock.h ImuBlock.c
  group flycontrolblock
    ../../libs/application/flycontrolblock/: FlyControlBlock.h FlyControlBlock.c HoldAltitudeMode.c HoldAltitudeMode.h BasicFlyMode.h BasicFlyMode.c GeneralFly.c GeneralFly.h AnalystControl.c AnalystControl.h HoldPositionMode.c HoldPositionMode.h
  group controlmotorblock
    ../../libs/application/motorcontrol/: MotorControlBlock.c MotorControlBlock.h
  group altitudecalibrationprogram
    ../../miniprogram/altitudecalibrationprogram/: AltitudeCalibrationProgram.c AltitudeCalibrationProgram.h
  group gyrocalibprogram
    ../../miniprogram/GyroCalibrationProgram/: GyroCalibrationProgram.h GyroCalibrationProgram.c
  group debug
    ../../miniprogram/debug/: DebugTime.c DebugTime.h
  group Main
    ../: main.c main.h
software components: CMSIS:CORE 5.0.0
